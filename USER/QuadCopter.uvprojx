# Keil uVision project QuadCopter.uvprojx, settings and files
target QuadCopter (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EXTI +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\USMART;..\HARDWARE\Attitude_Count;..\HARDWARE\Data_ReadWrite;..\HARDWARE\Data_Trans;..\HARDWARE\DMA_Config;..\HARDWARE\EEPROM;..\HARDWARE\LED;..\HARDWARE\MOTOR;..\HARDWARE\PID_Control;..\HARDWARE\PWM_Capture;..\HARDWARE\RC_Config;..\HARDWARE\TIM4;..\HARDWARE\USART1;..\HARDWARE\MPU6050;..\HARDWARE\BMP085;..\HARDWARE\HMC5883L;..\HARDWARE\ULTRASONIC;..\HARDWARE\FLOW
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/Attitude_Count/: Attitude_Count.c
    ../HARDWARE/Data_ReadWrite/: Data_ReadWrite.c
    ../HARDWARE/Data_Trans/: Data_Trans.c
    ../HARDWARE/DMA_Config/: DMA_Config.c
    ../HARDWARE/EEPROM/: eeprom.c
    ../HARDWARE/MOTOR/: Motor.c
    ../HARDWARE/MPU6050/: IIC.c MPU6050.c
    ../HARDWARE/PID_Control/: PID_Control.c Height_Control.c
    ../HARDWARE/PWM_Capture/: PWM_Capture.c
    ../HARDWARE/RC_Config/: RC_Config.c
    ../HARDWARE/USART1/: Usart1.c
    ../HARDWARE/HMC5883L/: HMC5883L.c
    ../HARDWARE/BMP085/: BMP085.c
    ../HARDWARE/ULTRASONIC/: Ultrasonic.c
    ../HARDWARE/LED/: Led.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c
